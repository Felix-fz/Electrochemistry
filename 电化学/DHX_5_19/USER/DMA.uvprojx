# Keil uVision project DMA.uvprojx, settings and files
target DMA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\SYSTEM\msg;..\SYSTEM\sys;..\SYSTEM;..\USER;..\SYSTEM\ADS1220;..\HARDWARE\SPI;..\SYSTEM\DAC8552;..\SYSTEM\DAC8563;..\USER;..\SYSTEM\usart2;..\SYSTEM\adc;..\HARDWARE\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/SPI/: spi2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/msg/: mymsg.c
    ../SYSTEM/ADS1220/: ads1220.c
    ../SYSTEM/DAC8563/: dac8563.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/usart2/: usart2.c
    ../HARDWARE/ESP8266/: esp8266.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_adc.c
